# Keil uVision project GPIO.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GPIO
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=4
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Common
    ../ARM_project/Src/MCAL/Common/: STD_TYPES.h
  group GPIO
    ./: GPIO_interface.h GPIO_private.h GPIO_config.h GPIO_program.c GPIO_config.c
  group App
    ./: main.c app.h
  group SYSTICK
    ./: SYSTICK_interface.h SYSTICK_program.c SYSTICK_private.h SYSTICK_config.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
